SUMMARY = "bluepy packages"

inherit packagegroup

RDEPENDS_${PN} = " \
    bluepy \
"
