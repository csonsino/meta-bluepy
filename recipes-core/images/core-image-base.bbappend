
IMAGE_INSTALL += " \
    packagegroup-bluepy \
"
